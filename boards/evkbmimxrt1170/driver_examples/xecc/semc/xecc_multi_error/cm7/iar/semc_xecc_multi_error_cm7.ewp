# IAR project semc_xecc_multi_error_cm7.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1176DVMAA_cm7; USE_SDRAM; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../../devices/MIMXRT1176; ../../../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../../../components/uart; ../../../../../../../../components/serial_manager; ../../../../../../../../components/lists; ../../../../../../../../devices/MIMXRT1176/utilities; ../../../../../../../../devices/MIMXRT1176/xip; ../../../../../../xip; ../../../../../../../../CMSIS/Core/Include; ../../../../../../../../devices/MIMXRT1176/utilities/str
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: semc_xecc_multi_error_cm7.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1176DVMAA_cm7; USE_SDRAM; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkConfigDefines: __use_flash64MB__=1
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1176DVMAA_cm7; USE_SDRAM; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1176DVMAA_cm7; USE_SDRAM; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkConfigDefines: __use_flash64MB__=1
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../../../../CMSIS/Core/Include/: cachel1_armv7.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../../../../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    ../../../../../../../../components/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    ../../../../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../../../../devices/MIMXRT1176/drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_mu.c fsl_mu.h fsl_pit.c fsl_pit.h fsl_pmu.c fsl_pmu.h fsl_semc.c fsl_semc.h fsl_soc_src.c fsl_soc_src.h fsl_xecc.c fsl_xecc.h
    ../../../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group evkbmimxrt1170
    ../: evkbmimxrt1170_connect_cm4_cm7side.jlinkscript
  group source
    ../: app.h xecc_multi_error.c
  group startup
    ../../../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group utilities
    ../../../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
    ../../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
